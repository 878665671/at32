# Keil uVision project at32f407_LED.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F437VGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.3
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: at32f407_new_test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F437VGT7,USE_STDPERIPH_DRIVER,AT_START_F437_V1
  c include: ..\at32fw\inc;..\bsp;..\user\inc;..\cmsis\cm4\device_support;..\cmsis\cm4\core_support;..\device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../user/src/: at32f435_437_clock.c at32f435_437_int.c main.c
  group bsp
    ../bsp/: bsp_led.c
  group device
    ../device/: at32f435_437_board.c device_gpio.c device_gpio.h
  group at32fw
    ../at32fw/src/: at32f435_437_acc.c at32f435_437_adc.c at32f435_437_can.c at32f435_437_crc.c at32f435_437_crm.c at32f435_437_dac.c at32f435_437_debug.c at32f435_437_dma.c at32f435_437_dvp.c at32f435_437_edma.c at32f435_437_emac.c at32f435_437_ertc.c at32f435_437_exint.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_misc.c at32f435_437_pwc.c at32f435_437_qspi.c at32f435_437_scfg.c at32f435_437_sdio.c at32f435_437_spi.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_usb.c at32f435_437_wdt.c at32f435_437_wwdt.c at32f435_437_xmc.c
  group cmsis
    ../cmsis/cm4/device_support/: system_at32f435_437.c
    ../cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
  group readme
    ../readme/: readme.txt
